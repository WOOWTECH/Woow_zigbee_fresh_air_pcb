# Repository WOOWTECH/Woow_zigbee_fresh_air_pcb

File README.md:

# Woow Zigbee 新風控制器 PCB（WO_30109）

220V 供電、4 路繼電器輸出的 Zigbee 新風（換氣扇）控制板。V3.0 起由一顆 **ESP32-C6** 同時負責 Zigbee 3.0 連網與控制，433MHz 遙控由 **SYN480R** 接收、ESP32 解碼（V2.0 以前是 STM32F103＋Tuya ZS3L＋EPA09-4D 模組）。

這個 repo 是把原設計 **V1.3**（Altium，外包設計）完整轉成 **KiCad 10**，用 git 做版控，並在 **V2.0** 修掉安規問題。

| 版本 | 狀態 | 說明 |
|---|---|---|
| `v1.3` | 參考用，**不可量產** | 原設計忠實重繪（原理圖＋PCB）。市電與低壓 GND 只隔 0.127mm。（`v1.3-baseline` 只含原理圖） |
| `v2.0` | **DRC 0 錯誤**（已合併 `main`） | 市電隔離 ≥6.4mm、保險絲＋壓敏電阻、降壓電源、Zigbee 串口 |
| `v3.0` | ERC/DRC 0；韌體 CI 綠燈 | ESP32-C6 單晶片 Zigbee＋SYN480R 433MHz，全部主料 JLC 可貼；市電區沿用 V2.0。見 [CHANGELOG](CHANGELOG.md#30--esp32-c6-單晶片syn480r) |
| `v3.4` | **目前版本**（ERC/DRC 0），**待打樣實測** | 照外殼 4-02-3（88×72×59 導軌盒）放回原板框：DI 2.54mm、NFC 外接 FPC 天線、P2 改測試點。見 [V3.4 驗證報告](docs/verification/V3.4.md) |
| `v3.3` | ⛔ 放不進外殼（板子加高到 107mm） | 加 NFC 設定介面（ST25DV04KC＋板上印刷線圈），J5 改到左側板邊。見 [V3.3 驗證報告](docs/verification/V3.3.md) |
| `v3.2` | ⛔ 放不進外殼（板子加高到 93mm） | 上緣左半段加長 10mm（L 形）加 4 路光耦 DI（乾接點／5–24VDC，NPN／PNP）、拿掉指撥。見 [V3.2 驗證報告](docs/verification/V3.2.md)（含 J5 接線） |
| `v3.1` | 只換值、不改佈線；ERC/DRC 0 | 433 匹配重新選值（失配 8–13dB → 3–5.3dB）、繼電器 PWM 降壓保持（取消 ≤3 顆限制）、續流改 Schottky、CPL 角度修正。見 [V3.1 驗證報告](docs/verification/V3.1.md) |

| V3.0 正面（零件面） | V3.0 背面 |
|---|---|
|  |  |

背面圖中藍色是 GND 鋪銅，白色帶是市電周圍 6.4mm 的安全帶（DRC 規則自動退讓）。完整原理圖：[V3.0](docs/images/schematic_v3.0.png)／[V2.0](docs/images/schematic_v2.0.png)。V3.0 左緣是 ESP32-C6 模組（天線端下方禁銅），左上是 SYN480R 433MHz 接收。

---

## 目錄

- [電路架構](#電路架構)
- [V1.3 → V2.0 改了什麼](#v13--v20-改了什麼)
- [安規隔離設計](#安規隔離設計)
- [Repo 結構](#repo-結構)
- [怎麼改設計（範例）](#怎麼改設計範例)
- [版本控制流程](#版本控制流程)
- [自動檢查（CI）](#自動檢查ci)
- [設計驗證報告](docs/verification/README.md)
- [主要料件](#主要料件)
- [已知限制與待辦](#已知限制與待辦)

---

## 電路架構

（V3.0；V2.0 以前低壓區是 STM32F103＋Tuya ZS3L＋EPA09-4D）

```mermaid
flowchart LR
    subgraph MAINS["⚡ 市電區（230VAC）"]
        P1["P1 市電輸入<br/>L / N"] --> F1["F1 保險絲<br/>T3.15A"]
        F1 --> RV1["RV1 壓敏電阻<br/>07D471K"]
        F1 --> IRM["U2 IRM-02-12<br/>AC→12V 2W<br/>（4.2kV 隔離）"]
        F1 -->|"P3.1 AC_L 輸出"| P3
        K["K1–K4 繼電器接點<br/>COM / NO / NC"] --> P3["P3 8P 輸出端子<br/>接風扇／閥"]
    end
    subgraph SELV["🔋 低壓區（12V / 3.3V）"]
        IRM -->|"+12V"| BUCK["U4 AP63203<br/>12V→3.3V 降壓"]
        IRM -->|"+12V"| COIL["繼電器線圈<br/>Q1–Q4 Si2302 驅動"]
        BUCK -->|"+3V3"| MCU["U1 ESP32-C6-WROOM-1<br/>Zigbee 3.0＋控制（V3.0）"]
        BUCK --> RF["U3 SYN480R<br/>433MHz ASK 接收"]
        ANT["ANT1 17.3cm 天線"] --> RF
        RF -->|"RF_DATA → IO23<br/>韌體解 EV1527"| MCU
        MCU -->|"Relay_1–4（IO6/7/0/1）"| COIL
        UI["B1 按鍵(IO9 BOOT) / S1 指撥 / L1 燈 / P2 燒錄座"] --- MCU
    end
    COIL -.->|"線圈-接點 加強絕緣"| K
```

### 電源預算（12V，IRM-02-12 額定 167mA）

| 負載 | V1.3 | V2.0 |
|---|---|---|
| 4 顆繼電器全吸（33.3mA × 4） | 133mA | 133mA |
| 3.3V 側（約 40mA） | 線性穩壓：12V 端也是 ~45mA | 降壓：12V 端約 13mA |
| **合計** | **~178mA（超過額定）** | **~146mA（在額定內）** |

---

## V1.3 → V2.0 改了什麼

```mermaid
flowchart TB
    A["V1.3 問題"] --> B1["市電離 GND 鋪銅 0.127mm"]
    A --> B2["AC 入口沒保險絲、沒壓敏電阻"]
    A --> B3["LM1117 線性穩壓：發熱、MLCC 不穩、12V 預算超標"]
    A --> B4["ZS3L 只用 GPIO，UART 沒接"]
    B1 --> C1["DRC 規則：市電↔低壓 ≥6.4mm<br/>鋪銅自動退讓、低壓元件移出安全帶"]
    B2 --> C2["F1 T3.15A ＋ RV1 07D471K"]
    B3 --> C3["AP63203 同步降壓（陶瓷電容穩定、耐 32V）"]
    B4 --> C4["TXD→PA10、RXD←PA9、RST←PB1"]
```

完整清單見 [CHANGELOG.md](CHANGELOG.md)，原設計審查見 [docs/review](docs/review)。

---

## 安規隔離設計

依 IEC 60664-1（230VAC、過電壓類別 II、汙染等級 2）設定，寫在 [`WO30109_FreshAir.kicad_dru`](hardware/WO30109_FreshAir/WO30109_FreshAir.kicad_dru)，KiCad DRC 與鋪銅都會自動遵守：

| 位置 | 要求 | V1.3 實測 | V2.0 |
|---|---|---|---|
| 市電 ↔ 低壓（含 GND 鋪銅） | ≥ 6.4mm（加強絕緣；與 G5Q 繼電器本身設計值相同） | **0.127mm** | ≥ 6.4mm |
| 市電不同網路之間（L-N、各路輸出） | ≥ 1.5mm（功能絕緣；G5Q 相鄰接點腳本身 1.67mm） | 0.5mm | ≥ 1.5mm |
| 銅到板邊 | ≥ 0.5mm | 0.26mm | ≥ 0.5mm |
| 固定孔（非金屬化）到市電 | ≥ 2.3mm（M3 螺絲頭多出孔外 1.15mm＋餘量）；**須用尼龍螺絲** | 1.77mm | 2.40–2.90mm |

```mermaid
flowchart LR
    L["市電銅箔<br/>AC_L / AC_N / DO_*"] ---|"≥ 1.5mm"| L2["另一條市電銅箔"]
    L ---|"≥ 6.4mm 安全帶<br/>（不得有任何低壓銅）"| S["低壓銅箔<br/>GND / 3.3V / 12V / 訊號"]
```

**怎麼確認**：在 KiCad 開 PCB → 檢查 → 設計規則檢查（DRC），或命令列：

```bash
kicad-cli pcb drc --severity-error hardware/WO30109_FreshAir/WO30109_FreshAir.kicad_pcb
```

---

## Repo 結構

```text
.
├── hardware/
│   ├── WO30109_FreshAir/          # KiCad 專案（用 KiCad 10 開 .kicad_pro）
│   │   ├── WO30109_FreshAir.kicad_sch   # 原理圖（由 scripts 產生）
│   │   ├── WO30109_FreshAir.kicad_pcb   # PCB
│   │   ├── WO30109_FreshAir.kicad_dru   # 安規 DRC 規則
│   │   ├── WO30109_FreshAir.kicad_jobset # 一鍵產出（ERC/DRC/Gerber/BOM/STEP）
│   │   └── sym-lib-table / fp-lib-table # 指向 ../lib 的專案庫
│   └── lib/
│       ├── WOOW.kicad_sym         # 自訂符號：ZS3L、EPA09-4D
│       ├── WOOW.pretty/           # 自訂封裝（焊盤量測自原板）
│       └── WOOW.3dshapes/         # 自訂 3D 模型
├── docs/verification/             # 設計驗證報告
├── scripts/
│   ├── design.py                  # ★ 電路唯一來源：零件、腳位、網路、改版差異
│   ├── gen_schematic.py           # design.py → .kicad_sch
│   ├── make_footprints.py         # 產生 WOOW.pretty
│   ├── import_v13_pcb.py          # 原 Gerber → KiCad PCB（需原始 Gerber，不公開）
│   ├── upgrade_v20_pcb.py         # V2.0 擺件與市電入口走線
│   ├── mains_router.py            # 雙層格點佈線器（市電間 1.5mm、對低壓 6.4mm）
│   ├── route_v20.py               # Freerouting 低壓佈線 + 鋪銅
│   ├── route_leftovers.py         # 補繞 Freerouting 沒繞通的線
│   ├── build_v20.sh               # ★ 一鍵重建 V2.0 PCB
│   ├── build_v30.sh               # ★ 一鍵重建 V3.0 PCB（從標籤 v2.0）
│   ├── build_v34.sh               # ★ 一鍵重建 V3.4 PCB（目前版本；從 V3.1 換件擺件 → Freerouting）
│   ├── upgrade_v34_pcb.py         # V3.4 換件、擺件、套網表、拆低壓走線
│   ├── upgrade_v32_pcb.py         # V3.2／V3.3 PCB（已作廢：放不進外殼）
│   ├── nfc_coil.py                # NFC 印刷線圈電感與調諧電容計算
│   ├── make_jlc_files.py          # ★ JLC 下單檔：Gerber zip、BOM、CPL（含 JLC 旋轉修正）
│   ├── drc_summary.py             # DRC 結果摘要
│   ├── add_stitching.py           # GND 縫合過孔
│   ├── make_3d_models.py          # 自訂零件 3D 模型（STEP）
│   └── assign_3d.py               # 3D 模型掛到封裝
├── sim/                           # SPICE 模擬（ngspice）
├── docs/review/                   # 設計審查報告
├── .github/workflows/kicad-ci.yml # 自動 ERC / DRC / 生產檔
├── CHANGELOG.md
└── README.md
```

---

## 怎麼改設計（範例）

原理圖由 `scripts/design.py` 產生，**改電路請改 design.py，不要直接在 KiCad 手改原理圖**（下次產生會被蓋掉）。PCB 可以直接在 KiCad 改。

### 範例 1：把 R4（LED 限流）從 100Ω 改成 220Ω

```python
# scripts/design.py
add("R4", "Device:R", "220R", R0603, "C22962", {"1": led_net, "2": "LED_A"})
```

```bash
python scripts/gen_schematic.py 2.0          # 重新產生原理圖
kicad-cli sch erc hardware/WO30109_FreshAir/WO30109_FreshAir.kicad_sch
# 開 KiCad PCB → 工具 → 從原理圖更新 PCB（F8）
git switch -c fix/led-resistor
git commit -am "fix: R4 改 220R，降低 LED 亮度"
git push -u origin fix/led-resistor && gh pr create
```

### 範例 2：在 KiCad 圖形介面裡用 Git

KiCad 9 起專案管理器內建 Git（檔案樹會顯示修改狀態、可 commit / push / pull / 切分支）。KiCad 9.0.0 的 push/pull 帳密處理曾有回報問題，建議 commit 用 KiCad、push 用命令列或 `gh`：

1. 用 KiCad 開 `hardware/WO30109_FreshAir/WO30109_FreshAir.kicad_pro`
2. 左側檔案樹按右鍵 → **Git** → Commit / Push / Switch branch
3. 偏好設定 → Version Control 可設定作者與遠端更新頻率

### 範例 3：重建整片 V2.0 PCB

```mermaid
flowchart LR
    A["原 V1.3 Gerber<br/>（不公開）"] --> B["import_v13_pcb.py<br/>銅箔→KiCad、焊盤對位"]
    D["design.py<br/>V2.0 網表"] --> B
    B --> C["upgrade_v20_pcb.py<br/>擺件、市電入口"]
    C --> E["mains_router.py<br/>繼電器輸出 DO_*"]
    E --> F["Freerouting<br/>低壓網路"]
    F --> G["route_leftovers.py<br/>補線"]
    G --> H["鋪銅（DRC 規則退讓）"]
    H --> I["DRC 0 錯誤"]
```

```bash
# 需要 KiCad 10、Java 17、xvfb-run、Freerouting 1.9 jar、kicad-sch-api
ORIG_GERBER=/path/to/V1.3_gerber ./scripts/build_v20.sh
```

Freerouting 每次結果不完全一樣；跑完一定看最後的 DRC 摘要，`errors: {}` 且 `unconnected: 0` 才算成功。

---

## 版本控制流程

```mermaid
gitGraph
    commit id: "V1.3 原理圖重繪" tag: "v1.3-baseline"
    commit id: "V1.3 PCB 轉入 + 安規規則" tag: "v1.3"
    branch rev/v2.0
    checkout rev/v2.0
    commit id: "原理圖：保險絲/降壓/UART"
    commit id: "PCB：擺件、市電佈線、低壓自動佈線（DRC 0 錯）"
    checkout main
    merge rev/v2.0 tag: "v2.0"
    branch fix/xxx
    commit id: "小修正"
    checkout main
    merge fix/xxx
```

| 規則 | 說明 |
|---|---|
| `main` | 永遠是可以生產的狀態（CI 綠燈） |
| `rev/vX.Y` | 一次改版一個分支，完成後開 PR 合併 |
| `fix/…`、`feat/…` | 小修改 |
| 標籤 `vX.Y` | 送廠的版本；Gerber、BOM、座標檔附在 GitHub Release |
| commit 訊息 | `feat:` 新功能、`fix:` 修正、`docs:` 文件，內文寫「改了什麼、為什麼」 |

**為什麼 KiCad 適合 git**：`.kicad_sch`、`.kicad_pcb`、`.kicad_sym`、`.kicad_mod` 都是純文字（S-expression），`git diff` 看得到每一行的變化；暫存檔（`*.kicad_prl`、`*-backups/`、`fp-info-cache`）已在 `.gitignore` 排除。要看圖形化差異可用 [KiRI](https://github.com/leoheck/kiri) 或 [kicadiff](https://github.com/sksat/kicadiff)。

---

## 自動檢查（CI）

每次 push 或開 PR，GitHub Actions（`kicad/kicad:10.0` 容器）會：

```mermaid
flowchart LR
    A["git push / PR"] --> B["ERC<br/>原理圖電氣規則"]
    B --> C["DRC<br/>佈線＋市電安規"]
    C --> D["產生生產檔<br/>Gerber / 鑽孔 / 座標 / BOM / PDF"]
    D --> E["Actions Artifacts<br/>下載送 JLC"]
```

任何 ERC/DRC **錯誤**都會讓 CI 變紅燈，不能合併到 `main`。CI 也會跑 SPICE（繼電器關斷尖峰必須 < 20V）並輸出 STEP 3D 檔。

本機一鍵產出（不需要 GitHub）：KiCad 專案管理器點 `WO30109_FreshAir.kicad_jobset`，或

```bash
cd hardware/WO30109_FreshAir && kicad-cli jobset run --file WO30109_FreshAir.kicad_jobset WO30109_FreshAir.kicad_pro
```

---

## 設計驗證

完整報告：**[V3.0](docs/verification/V3.0.md)**（ESP32-C6＋SYN480R，含電源預算、433 匹配模擬）／[V2.0](docs/verification/README.md)

| 項目 | 結果 |
|---|---|
| ERC／DRC（含市電安規）／parity | 0／0／0 |
| SPICE（ngspice） | 8 子電路全過；繼電器關斷尖峰 12.8V（拿掉續流二極體時 251V） |
| PCB 計算器（IPC-2221） | ⚠️ 市電 1.5mm 線在 1oz 銅剛好等於保險絲 3.15A；>3A 負載請選 2oz 銅 |
| 熱分析 | 最壞 2.6W；IRM-02 在此負載環境上限約 74°C |
| EMC 預檢 | 風險分數 49/100，多數為市電隔離的刻意設計；量產前需實測預掃 |
| 3D／STEP | 正面最高 16.9mm、背面 4.3mm；STEP 由 CI 產生 |
| Jobset | 8/8 工作成功（KiCad 原生一鍵產出） |

---

## 主要料件

| 位號 | 料件 | LCSC | 備註 |
|---|---|---|---|
| U1 | ESP32-C6-WROOM-1-N8（V3.0） | C5366877 | Zigbee 3.0／Wi-Fi 6／BLE 5，PCB 天線（V2.0：STM32F103C8T6 C8734） |
| U2 | MEAN WELL IRM-02-12 | C7211213 | 230VAC→12V 2W |
| U3 | SYN480R（V3.0） | C916347 | 433.92MHz ASK 接收；Y1 13.52127MHz C654957（V2.0：Tuya ZS3L，JLC 無料） |
| U4 | AP63203WU-7（V2.0） | C780769 | 12V→3.3V 降壓 |
| L2 | SWPA4030S3R9MT 3.9µH（V2.0） | C96899 | 規格書 Table 2 建議值 |
| K1–K4 | Omron G5Q-1 DC12 | C397244 | 250VAC：NO 5A、NC 3A |
| F1 | 保險絲 T3.15A 250V（V2.0） | — | TR5 座，手焊 |
| RV1 | 07D471K（V2.0） | C28756 | |
| ANT1 | 433MHz 1/4 波長天線（V3.0） | — | 17.3cm 導線或彈簧天線，手焊（V2.0：RF1 EPA09-4D，規格書未公開） |

完整 BOM 由 CI 產生（`*-bom.csv`）。

---

## DI 輸入接線（J5）

| J5 腳 | 1 | 2 | 3 | 4 | 5 | 6 | 7 |
|---|---|---|---|---|---|---|---|
| 名稱 | +12V（限流 8mA） | IN1 | IN2 | IN3 | IN4 | COM | GND |

V3.4 的 J5 在上緣開窗（P1 左邊），2.54mm 間距，**由左往右**是 1→7（電線最大 0.5mm²）。V3.3 直立在左側板邊（已作廢）。

- **乾接點**（按鈕、溫控器、門磁）：COM（6）接 GND（7），每個接點接在 +12V（1）和 INx 之間。
- **NPN 輸出**：COM 接外部 +5～24V，INx 接感測器輸出。
- **PNP 輸出**：COM 接外部 0V，INx 接感測器輸出。
- 光耦隔離 2.5kVrms；用乾接點接法時，外部線路和板子的 SELV 低壓共地。
- 細節見 [V3.2 驗證報告 §2](docs/verification/V3.2.md#2-j5-接線)。

## 外殼

精鋼塑模 **4-02-3**：35mm 導軌式開關盒，外形 88×72×59mm，ABS。板子用 4 根 M3 螺絲鎖在底座，間距 50×50mm。

- P1（AC IN）、J5（DI）從上方開窗出線；P3（AC OUT）從下方開窗出線。
- NFC：FPC 天線貼在前蓋凸起部位的內側，接到板上 J6。
- 固定螺絲用尼龍螺絲（市電對可觸及金屬要 6.4mm）。

## 已知限制與待辦

- **電源預算（V3.1）**：IRM-02-12 額定 167mA。韌體讓繼電器全壓吸合 100ms 後改 20kHz、60% PWM 保持（Omron G5Q-1 規定保持電壓 ≥30%），每顆 12V 端 33.3→14.4mA；4 顆可同時吸合，最壞（3 顆保持＋1 顆吸合＋發射峰值）約 135mA。V3.0 是韌體限制 ≤3 顆。標準版 G5Q-1 沒有 Omron 的 PWM 背書（只有 -PW 型有，JLC 無料），打樣要在最高溫實測保持與釋放。見 [V3.1 驗證報告](docs/verification/V3.1.md#2-電源繼電器-pwm-降壓保持)。
- **433MHz**：SYN480R 只輸出解調後的原始波形，遙控器編碼（EV1527／PT2262）要在 ESP32 韌體解。V3.0 的匹配值照規格書典型應用，但用同系列 Micrel 原廠實測輸入阻抗算，峰值落在 210–230MHz；V3.1 重新選值（同拓撲、同佈線）。晶片真實阻抗原廠沒公開，打樣後要用 VNA 量 S11 或遙控器實測距離微調。見 [V3.1 驗證報告](docs/verification/V3.1.md#1-433mhz-匹配)。
- **V3.0 ESP32 天線**：模組天線端貼左板邊、下方兩層禁銅；外殼若是金屬或天線端靠近金屬，Zigbee 距離會明顯縮短，必要時改外接天線版 ESP32-C6-WROOM-1U（腳位相同、本體短 6.3mm；2026-10-03 查 JLC 0 庫存，要客供）。
- **繼電器負載**：G5Q-1 在 250VAC 只有 NO 5A／NC 3A，沒有馬達額定；多段速風扇要在韌體互鎖，避免兩檔同時吸合。
- **固定孔一律用尼龍螺絲／絕緣支柱**：V2.0 孔邊到市電銅箔 2.4–2.9mm（DRC 規則 `hole_to_mains` ≥ 2.3mm），足夠避開螺絲頭，但達不到市電對可觸及金屬的 6.4mm，所以不能用金屬螺絲接金屬外殼。
- **韌體**：V3.0 韌體在 [`firmware/`](firmware/README.md)（ESP-IDF v5.5.4＋esp-zigbee-lib v2）：Zigbee 路由器 4 個開關端點、指撥 4 種模式與風速互鎖、EV1527 遙控器學習、按鍵／燈號。主機端單元測試與完整編譯都在 CI。實際入網與遙控器相容性要打樣後驗證。
- 原始 Altium 檔、Gerber、請款單等外包資料**不公開**，不在本 repo。

---

## 資料來源

- MEAN WELL IRM-02 規格書：<https://www.meanwell.com/Upload/PDF/IRM-02/IRM-02-SPEC.PDF>
- Omron G5Q：<https://omronfs.omron.com/en_US/ecb/products/pdf/en-g5q.pdf>
- Tuya ZS3L：<https://developer.tuya.com/en/docs/iot/zs3l?id=K97r37j19f496>
- Espressif ESP32-C6-WROOM-1 規格書 v1.4：<https://documentation.espressif.com/esp32-c6-wroom-1_wroom-1u_datasheet_en.pdf>
- JSMSEMI SYN480R 規格書：LCSC C916347
- Diodes AP63203：<https://www.diodes.com/assets/Datasheets/AP63200-AP63201-AP63203-AP63205.pdf>
- IEC 60664-1 間距表（TI SLUP421）：<https://www.ti.com/lit/pdf/SLUP421>
- KiCad Git 整合：<https://docs.kicad.org/9.0/en/kicad/kicad.html>

## KiCad design hardware/WO30109_FreshAir/WO30109_FreshAir.kicad_pcb

Parts:
ANT1: 433MHz 1/4λ 17.3cm; TestPoint_THTPad_D2.0mm_Drill1.0mm
B1: TS-1088-AR02016; SW_SPST_TS-1088; LCSC C720477
C1, C7, C13: 22uF 25V; C_0805_2012Metric; LCSC C45783
C2, C9, C12, C14, C23: 100nF; C_0603_1608Metric; LCSC C14663
C5, C17: 1uF; C_0603_1608Metric; LCSC C15849
C6: 10uF 25V; C_0603_1608Metric; LCSC C96446
C8: 10uF; C_0603_1608Metric; LCSC C19702
C15, C16: 2.7pF C0G; C_0603_1608Metric; LCSC C162221
C18, C19, C20, C21: 10nF; C_0603_1608Metric; LCSC C57112
C22: 8.2pF C0G; C_0603_1608Metric; LCSC C1685
C24: DNP trim; C_0603_1608Metric
D1, D2, D3, D4: B5819W; D_SOD-123; LCSC C8598
F1: T3.15A 250V TR5; Fuseholder_TR5_Littelfuse_No560_No460; LCSC C178794
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J5: DI 12V/IN1-4/COM/GND; TerminalBlock_Pluggable_1x07_P2.54mm_Horizontal; LCSC C577599
J6: NFC ANT; Molex_MicroLockPlus_505568-0271_1x02_P1.25mm_Vertical; LCSC C5350147
K1, K2, K3, K4: G5Q-1 DC12; Relay_SPDT_Omron-G5Q-1_Tight; LCSC C397244
L1: Blue; LED_0603_1608Metric; LCSC C965807
L2: 3.9uH; L_Sunlord_SWPA4030S; LCSC C96899
L3: 47nH; L_0603_1608Metric; LCSC C29683
L4: 33nH; L_0603_1608Metric; LCSC C35050
P1: AC IN 230V; TerminalBlock_Pluggable_1x02_P5.00mm_Horizontal; LCSC C441193
P2: PROG; ProgPads_2x03_P2.54mm
P3: AC OUT; TerminalBlock_Pluggable_1x08_P5.08mm_Horizontal; LCSC C441210
Q1, Q2, Q3, Q4: Si2302CDS; SOT-23; LCSC C5224182
R1, R2, R3, R9, R10, R11, R12, R24, R25: 10k; R_0603_1608Metric; LCSC C25804
R4: 100R; R_0603_1608Metric; LCSC C22775
R5, R6, R7, R8: 1k; R_0603_1608Metric; LCSC C21190
R14: 0R; R_0603_1608Metric; LCSC C21189
R15, R16, R17, R18: 3.3k; R_1206_3216Metric; LCSC C26032
R23: 1.5k; R_1206_3216Metric; LCSC C26030
RV1: 07D471K; RV_Disc_D7mm_W3.4mm_P5mm; LCSC C28756
U1: ESP32-C6-WROOM-1-N8; Espressif_ESP32-C6-WROOM-1; LCSC C5366877
U2: IRM-02-12; Converter_ACDC_MeanWell_IRM-02-xx_THT; LCSC C7211213
U3: SYN480R; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C916347
U4: AP63203WU-7; TSOT-23-6; LCSC C780769
U5: TLP290-4; SOP-16_4.55x10.3mm_P1.27mm; LCSC C39031
U6: ST25DV04KC-IE6S3; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C3304276
Y1: 13.52127MHz 20pF; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C654957

Connections:
/+3V3: C1.1, C2.1, C7.1, C8.1, C9.1, C13.1, C17.1, C23.1, L2.2, P2.1, R1.1, R2.1, R3.1, R24.1, R25.1, U1.2 (3V3), U3.3 (VDD), U4.1 (FB), U6.8 (VCC)
/+12V: C6.1, C14.1, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), K1.1, K2.1, K3.1, K4.1, R23.1, U2.4 (+Vo), U4.2 (EN), U4.3 (IN)
/+12V_DI: J5.1, R23.2
/AC_L: F1.2, P3.1, RV1.1, U2.1 (AC/N)
/AC_L_IN: F1.1, P1.1
/AC_N: P1.2, RV1.2, U2.2 (AC/L)
/BOOT: B1.2, P2.6, R2.2, U1.15 (IO9)
/BST: C12.1, U4.6 (BST)
/COIL1: D1.2 (A), K1.5, Q1.3 (D)
/COIL2: D2.2 (A), K2.5, Q2.3 (D)
/COIL3: D3.2 (A), K3.5, Q3.3 (D)
/COIL4: D4.2 (A), K4.5, Q4.3 (D)
/DI_1: C18.1, U1.26 (IO3), U5.16 (C1)
/DI_2: C19.1, U1.23 (IO15), U5.14 (C2)
/DI_3: C20.1, U1.20 (IO22), U5.12 (C3)
/DI_4: C21.1, U1.19 (IO21), U5.10 (C4)
/DI_A1: R15.2, U5.1 (A1)
/DI_A2: R16.2, U5.3 (A2)
/DI_A3: R17.2, U5.5 (A3)
/DI_A4: R18.2, U5.7 (A4)
/DI_COM: J5.6, U5.2 (K1), U5.4 (K2), U5.6 (K3), U5.8 (K4)
/DI_IN1: J5.2, R15.1
/DI_IN2: J5.3, R16.1
/DI_IN3: J5.4, R17.1
/DI_IN4: J5.5, R18.1
/DO_1_NO: K1.3, P3.8
/DO_2_NO: K2.3, P3.7
/DO_3_NC: K3.4, P3.5
/DO_3_NO: K3.3, P3.6
/DO_4_NC: K4.4, P3.3
/DO_4_NO: K4.3, P3.4
/DO_COM: K1.2, K2.2, K3.2, K4.2, P3.2
/EN: C5.1, P2.5, R1.2, U1.3 (EN)
/G1: Q1.1 (G), R5.2, R9.1
/G2: Q2.1 (G), R6.2, R10.1
/G3: Q3.1 (G), R7.2, R11.1
/G4: Q4.1 (G), R8.2, R12.1
/GND: B1.1, C1.2, C2.2, C5.2, C6.2, C7.2, C8.2, C9.2, C13.2, C14.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C23.2, J5.7, L1.1 (K), L3.2, L4.2, P2.2, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), R9.2, R10.2, R11.2, R12.2, R14.2, U1.1 (GND), U1.28 (GND), U1.29 (GND), U2.3 (-Vo), U3.1 (GND), U3.6 (SHUT), U4.4 (GND), U5.9 (E4), U5.11 (E3), U5.13 (E2), U5.15 (E1), U6.4 (VSS), Y1.2 (GND), Y1.3 (X2), Y1.4 (GND)
/IO8: R3.2, U1.10 (IO8)
/LED: R4.1, U1.27 (IO2)
/LED_A: L1.2 (A), R4.2
/NFC_AC0: C22.1, C24.1, J6.2, U6.2 (AC0)
/NFC_AC1: C22.2, C24.2, J6.1, U6.3 (AC1)
/NFC_SCL: R25.2, U1.17 (IO19), U6.6 (SCL)
/NFC_SDA: R24.2, U1.18 (IO20), U6.5 (SDA)
/RF_ANT: ANT1.1, C15.1, C16.1, L3.1
/RF_DATA: U1.21 (IO23), U3.5 (DO)
/RF_IN: C15.2, L4.1, U3.2 (ANT)
/RF_SQ: R14.1, U3.7 (SQ)
/RF_XTAL: U3.8 (RO), Y1.1 (X1)
/Relay_1: R5.1, U1.6 (IO6)
/Relay_2: R6.1, U1.7 (IO7)
/Relay_3: R7.1, U1.8 (IO0)
/Relay_4: R8.1, U1.9 (IO1)
/SW: C12.2, L2.1, U4.5 (SW)
/U0RXD: P2.4, U1.24 (RXD0/IO17)
/U0TXD: P2.3, U1.25 (TXD0/IO16)

Notes on the sheet:
市電輸入／電源
MCU
Zigbee / RF / 介面
繼電器
DI 輸入（光耦隔離）
NFC 設定介面

Board: 2 copper layers, 63.4 x 83.1 mm, 76 parts (47 on the bottom side), 57 nets.

## Code that names these connections

File firmware/main/board.h:

/* WO_30109 腳位（hardware/…/WO30109_FreshAir.kicad_sch，scripts/design.py）。板子版本在 menuconfig 選 */
#pragma once
#include "sdkconfig.h"
#define PIN_RELAY_1   6    /* U1 pin6  → R5 → Q1 閘極（10k 下拉，開機不吸合） */
#define PIN_RELAY_2   7
#define PIN_RELAY_3   0
#define PIN_RELAY_4   1
/* J5 IN1–IN4 經 U5 TLP290-4：接通＝低電位（內建上拉）。V3.1 以前沒有 DI（那時 IO10/IO11 是指撥） */
#if CONFIG_FA_BOARD_V32
#define PIN_DI_1      22
#define PIN_DI_2      21
#define PIN_DI_3      20
#define PIN_DI_4      19
#else                      /* V3.3：DI 與 NFC I2C 照左右順序進 U1 上排（佈線不交叉） */
#define PIN_DI_1      3
#define PIN_DI_2      15   /* strapping 腳，但只在燒了 JTAG eFuse 時讀，出廠不受影響 */
#define PIN_DI_3      22
#define PIN_DI_4      21
#define PIN_NFC_SDA   20   /* U6 ST25DV04KC，R24 10k 上拉 */
#define PIN_NFC_SCL   19   /* R25 10k 上拉 */
#endif
#define PIN_BUTTON    9    /* B1，按下 = 低；也是 BOOT strapping 腳 */
#define PIN_LED       2    /* L1 藍燈，高電位亮 */
#define PIN_RF_DATA   23   /* SYN480R DO */

File scripts/design.py (part):

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                  # 調諧：Molex 1462360001-PS 表列 La 3.3µH、Ca 4.9pF；ST25DV 內建 28.5pF →
                  # C22 = 1/(ω²·3.3µH) − 28.5 − 4.9 ≈ 8.4pF → 8.2pF C0G（諧振約 13.58MHz）。C24 空位留給實測微調
            add("J6", "Connector_Generic:Conn_01x02", "NFC ANT", "WOOW:Molex_MicroLockPlus_505568-0271_1x02_P1.25mm_Vertical",
                "C5350147", {"1": "NFC_AC1", "2": "NFC_AC0"})   # 天線不分極性：Pin1／2 對調讓轉 180° 後接上原走線；MP 不接
            add("C22", "Device:C", "8.2pF C0G", C0603, "C1685", {"1": "NFC_AC0", "2": "NFC_AC1"})
        else:
            add("L5", "Device:L", "NFC coil 1.27uH", "WOOW:NFC_Coil_14.9x14.6mm_8T", "", {"1": "NFC_AC0", "2": "NFC_AC1"})
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        "電源預算：Zigbee TX +12dBm 峰值 185mA@3.3V ≈ 12V 側 58mA；繼電器 4 顆全吸 133mA → 合計 ~192mA 超過 IRM-02-12 額定 167mA，韌體限制同時吸合 ≤3 顆或 TX ≤0dBm（見 README）",
    ],
    "2.0": [
        "F1 慢斷保險絲 T3.15A 串在 AC_L 入口（同時保護 IRM 與 P3 pin1 供給 DO_COM 的風扇迴路）",
        "RV1 壓敏電阻 07D471K 跨 L-N（突波）",
        "電源預算：3.3V 改降壓後 12V 側只剩約 13mA，4 顆繼電器全吸 133mA，合計約 146mA < IRM-02-12 額定 167mA（保留原電源與位置）",
        "U4 LM1117 線性 -> AP63203WU 同步降壓：免散熱、陶瓷電容穩定、輸入耐 32V（IRM OVP 16.2V 也安全）",
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